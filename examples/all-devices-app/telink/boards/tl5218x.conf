## examples/platform/telink/tests/battery_monitor_logic/testcase.yaml
```yaml
tests:
  battery_monitor.logic:
    platform_allow:
      - native_sim
    tags:
      - battery
    timeout: 30
```
